# Keil uVision project oven.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: oven +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\api;..\Gen;..\core\ComIf\api;..\core\SysOS\api
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group project
    ./: main.c ceco.c
  group core
    ../core/SysOS/src/: SysOS.c
    ../core/Buffer/src/: Buffer.c
    ../core/ComIf/src/: ComIf.c ComIf_CalcChecksum.c ComIf_RxIndication.c ComIf_RxRequest.c ComIf_Transmit.c ComIf_TxShadowBuffer.c
    ../core/HMI/: HMI.c
    ../core/IOs/: portsInit.c IOIF.c heaterControl.c steamControl.c motoControl.c drainValveControl.c doorControls.c
    ../core/sensors/: spiSensors.c flowSensor.c
    ../core/Debug/src/: Debug.c
    ../core/Diag/src/: Diag.c
  group Gen
    ../Gen/: SysOs_Processes.c Buffer_Config.c ComIf_Config.c Diag_Config.c
  group stm32hal
    ../stm32hal/dac/: DAC.c
    ../stm32hal/gpio_driver/: GPIO.c
    ../stm32hal/pll/: PLL.c
    ../stm32hal/systick/: Systick.c
    ../stm32hal/uart/: Uart.c
    ../stm32hal/spi/: SPI.c
    ../stm32hal/WDG/: WDG.c
  group app
    ../app/: recipeConfigSettings.c Wash.c Cooking.c CookingConfig.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.4.0
